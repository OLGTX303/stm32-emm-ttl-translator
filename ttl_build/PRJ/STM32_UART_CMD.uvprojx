# Keil uVision project STM32_UART_CMD.uvprojx, settings and files
target STM32_PUL_WHILE (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\APP;..\BSP;..\CMSIS;..\LIB\STM32F10x_StdPeriph_Lib_V3.5.0\inc;..\DRIVERS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ../APP/: main.c stm32f10x_conf.h stm32f10x_it.c translator.c translator.h
  group BSP
    ../BSP/: motor_config.h usart.c usart.h board.c board.h
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group STM32F10x_StdPeriph_Lib_V3.5.0
    ../LIB/STM32F10x_StdPeriph_Lib_V3.5.0/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c
